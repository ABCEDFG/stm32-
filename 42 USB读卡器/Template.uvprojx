# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\Src\USB\CONFIG;.\Src\USB\STM32_USB-FS-Device_Driver\inc;.\APP\sd_sdio;.\Src\FatFs\fatfs_app;.\Src\FatFs\src;.\APP\malloc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_sdio.c stm32f10x_dma.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/sd_sdio/: sd_sdio.c
    ./APP/malloc/: malloc.c
  group Src
    ./Src/FatFs/fatfs_app/: fatfs_app.c
    ./Src/FatFs/src/: diskio.c ff.c
    ./Src/FatFs/src/option/: cc936.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group USB_Core
    ./Src/USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_Conflg
    ./Src/USB/CONFIG/: hw_config.c usb_desc.c usb_istr.c usb_endp.c usb_prop.c usb_pwr.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_scsi.c
