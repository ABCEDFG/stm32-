# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\sd_sdio;.\FatFs\src;.\FatFs\fatfs_app;.\APP\malloc;.\APP\tftlcd;.\APP\Font;.\APP\flash;.\APP\spi;.\APP\key;.\APP\at24cxx;.\APP\I2C;.\APP\T9INPUT;.\APP\touch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/sd_sdio/: sd_sdio.c
    ./APP/malloc/: malloc.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/Font/: font_show.c font_update.c
    ./APP/flash/: flash.c
    ./APP/spi/: spi.c
    ./APP/key/: key.c
    ./APP/T9INPUT/: pinyin_input.c
    ./APP/touch/: touch.c
    ./APP/at24cxx/: at24cxx.c
    ./APP/I2C/: i2c.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group Fatfs
    ./FatFs/src/: diskio.c ff.c
    ./FatFs/src/option/: cc936.c
    ./FatFs/fatfs_app/: fatfs_app.c
