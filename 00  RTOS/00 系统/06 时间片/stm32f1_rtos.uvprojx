# Keil uVision project stm32f1_rtos.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: stm32f1_rtos
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\User;.\rtthread\3.0.3\bsp;.\rtthread\3.0.3\components\finsh;.\rtthread\3.0.3\include;.\rtthread\3.0.3\include\libc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./User/: main.c
  group rtt/ports
    ./rtthread/3.0.3/libcpu/arm/cortex-m3/: cpuport.c context_rvds.s
  group rtt/source
    ./rtthread/3.0.3/src/: scheduler.c thread.c kservice.c object.c clock.c idle.c irq.c timer.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
